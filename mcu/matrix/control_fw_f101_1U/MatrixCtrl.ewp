# IAR project MatrixCtrl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\Core\CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MatrixCtrl.bin
  ILINK.IlinkOutputFile: MatrixCtrl.out
  ILINK.IlinkIcfFile: Linker\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group CMSIS/StartUp
    Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group Library
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./: AT24XX.c Init.c Key.c Lcd_LM6060.c LcdData.c main.c MyLib.c MyUart.c stm32f10x_it.c Switch.c
