# Keil uVision project DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin --output ../output/DEMO.bin ../output/DEMO.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\STM32_FWLib\inc;..\STM32_FWLib\src;..\Code\LED;..\Code\SYSTICK;..\Code\KEY;..\Code\EXTI;..\Code\SPI;..\Code\USART;..\Code\WDG;..\Code\STMFLASH;..\Code\EXTI;..\Code\DISPLAY;..\Code\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/Startup/: startup_stm32f10x_md_vl.s
  group User
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h core_cm3.h
  group STM32_FWLib
    ../STM32_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_systick.c
    ../STM32_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h stm32f10x_systick.h
  group CODE
    ../Code/USART/: USART.c USART.h
    ../Code/LED/: led.c led.h
    ../Code/SYSTICK/: SYSTICK.c SYSTICK.h
    ../Code/WDG/: wdg.c wdg.h
    ../Code/DISPLAY/: display.c
    ../Code/KEY/: key.c
    ../Code/EEPROM/: eeprom.c
  group instruction
    ../: 备注.txt
