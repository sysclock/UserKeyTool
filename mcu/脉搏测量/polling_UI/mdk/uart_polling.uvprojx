# Keil uVision project uart_polling.uvprojx, settings and files
target uart_polling Debug (5060020::V5.06 (build 20)::ARMCC)
  device: MK24FN1M0xxx12 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.1
  cpu: IROM(0x00000000,0x00100000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_polling.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;..\display_data;..\MK24F12;..\MK24F12\drivers;..\CMSIS\Include;..\MK64F12\utilities;..\MK24F12;..\MK64F12
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../MK24F12/: system_MK24F12.h system_MK24F12.c
    ../MK24F12/arm/: startup_MK24F12.s
  group drivers
    ../MK24F12/drivers/: fsl_uart.c fsl_uart.h fsl_clock.c fsl_clock.h fsl_flash.c fsl_flash.h fsl_port.h fsl_smc.c fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_smc.h fsl_dspi.c fsl_dspi.h fsl_rtc.c fsl_rtc.h fsl_pit.c fsl_pit.h fsl_adc16.c fsl_adc16.h
  group source
    ../source/: lcd_spi.c lcd_spi.h flash_spi.c key.c MenuTbl.c uart.c main.c rtc.c pw1101_interact.c states.c bat_adc.c Queue.c
  group board
    ../source/: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../MK24F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group doc
    ../: 说明.txt
target uart_polling Release (ARM-ADS)
  device: MK24FN1M0xxx12 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.1
  cpu: as above
  output: uart_polling.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, FRDM_K64F, FREEDOM
  c misc: as above
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MK64F12/drivers;..;../../../../../../devices/MK64F12/utilities;../../../..;../../../../../../devices/MK64F12
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
