# Keil uVision project LED_GraphicProcessor_RD3.uvproj, settings and files
target LED_GraphicProcessor_RD3 (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LED_GraphicProcessor_RD3 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;    ../Middlewares/Third_Party/LwIP/system;    ../Middlewares/Third_Party/LwIP/src/include;    ../Middlewares/Third_Party/LwIP/src/include/ipv4;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Middlewares/Third_Party/LwIP/system/arch;    ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;    ../Middlewares/Third_Party/LwIP/src/include/lwip;    ../Middlewares/Third_Party/LwIP/src/include/netif;    ../Middlewares/Third_Party/LwIP/src/include/posix;    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;    ../Middlewares/Third_Party/LwIP/src/netif/ppp;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_rtc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c
  group Device
    ../Device/ClockGeneration/: SL38160.c SL38160Tbl.c
    ../Device/EEprom/: AT24C256.c
    ../Device/ADV7604Driver/: adv7604.C v4l2-dv-timings.C
    ../Device/InputFPGA/: InputFPGA.c t_InputFPGAScaler.c
    ../Device/GV7601/: gv7601.c
    ../Device/TVP5158/: TVP5158.c
  group Device SiI9136
    ../Device/SiI9136/: AV_Config.c eHDMI.c Globals.c HDCP.c SiI9136EDID.c TPI.c TPI_Access.c VideoModeTable.c
  group MultiSignalBoard
    ../MultiSignalBoard/: InputBoardADV7604.c InputBoardGraphicFPGA.c OutputBoardSiI9136.c Param.c t_InputGraphiFPGAInterface.c InputBoardGV7601.c InputBoardTVP5158.c
  group WindowsLayout
    ../WindowsLayout/: ScreenWindowlLayout.c SignalWindowsCrop.c
  group UserCommand
    ../User Command/: UserCommandPC_API.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/User
    ../Src/: ethernetif.c stm32f1xx_it.c lwip.c stm32f1xx_hal_msp.c main.c D_IIC.C D_IIC1.C D_IIC2.C D_IIC3.C Serial.c tcp_echoserver.c Timer.c InitDevice.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pap.c md5.c randm.c magic.c lcp.c ppp.c vj.c ppp_oe.c fsm.c chpms.c chap.c ipcp.c auth.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: msg_in.c asn1_dec.c msg_out.c mib2.c asn1_enc.c mib_structs.c
    ../Middlewares/Third_Party/LwIP/src/core/: dhcp.c lwip_timers.c netif.c udp.c dns.c memp.c sys.c tcp.c init.c raw.c pbuf.c stats.c tcp_out.c def.c tcp_in.c mem.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c netdb.c tcpip.c api_lib.c netbuf.c api_msg.c err.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c igmp.c ip_addr.c autoip.c ip_frag.c ip.c inet_chksum.c inet.c
