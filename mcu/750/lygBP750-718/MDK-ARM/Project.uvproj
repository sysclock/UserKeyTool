# Keil uVision project Project.uvproj, settings and files
target STM32F10X_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10X_XL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../User/: USART.c I2C.c date.c StateMachine.c StateData.c RTC.c SendMsg.c Strings.c MenuTbl.c flash.c main.c stm32f10x_it.c LCD.c Keypad.c delay.c web_server.c enc28j60.c spi_enc28j60.c ip_arp_udp_tcp.c Queue.c IO.c IT626X_drv.c IT626X_sys.c remote.c UserDef.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c
  group CMSIS
    ../User/: core_cm3.c system_stm32f10x.c
  group STM32_EVAL
    ../User/: stm32_eval.c
  group RVMDK
    ../Startup/: startup_stm32f10x_hd.s
  group Doc
    ./: readme.txt
  group Library
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB STM32F10xD.LIB
  group IIC Comm
    ../IIC Comm/: D_IIC0.C
  group System Code
    ../System Code/: Timer.c
  group MultiSignalBoard
    ../MultiSignalBoard/: BoardID.c Init.c InputBoardADV7604.c InputBoardGraphicFPGA.c InputBoardTVP5158.c OutputBoardSiI9136.c t_InputGraphiFPGAInterface.c InputBoardGV7601.c Param.c
  group Device Layer
    ../Device/GV7601/: gv7601.c
    ../Device/InputFPGA/: InputFPGA.c t_InputFPGAScaler.c
    ../Device/ClockGeneration/: SL38160.c SL38160Tbl.c
    ../Device/ADV7604Driver/: adv7604.C v4l2-dv-timings.C
    ../Device/TVP5158/: TVP5158.c
    ../Device/EEprom/: AT24C256.c AT24C04.c
    ../Device/AD9388A/: AD9388A.C
  group Device SiI9136
    ../Device/SiI9136/: AV_Config.c eHDMI.c Globals.c HDCP.c SiI9136EDID.c TPI.c VideoModeTable.c TPI_Access.c
  group WindowsLayout
    ../WindowsLayout/: ScreenWindowlLayout.c SignalWindowsCrop.c
  group UserCommand
    ../User Command/: UserCommandPC_API.c
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL, USE_STM32100B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target LED_MCU (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: xp750 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\User;..\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
